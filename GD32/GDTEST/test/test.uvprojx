# Keil uVision project test.uvprojx, settings and files
target test (ARM-ADS)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\APP;.\BSP;..\Firmware\CMSIS;..\Firmware\GD32F10x_standard_peripheral\Include;..\Firmware\CMSIS\GD\GD32F10x\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ./APP/: main.c usart_comm.c usart_comm.h ads124s08.c ads124s08.h thermocouple.c pcb_sensor.c speed_sensor.c thermocouple.h pcb_sensor.h speed_sensor.h
  group BSP
    ./BSP/: gd32f10x_it.c systick.c
  group FMW_CORE
    ../Firmware/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
    ../Firmware/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_md.s
  group FMW_PERI
    ../Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_gpio.c gd32f10x_rcu.c gd32f10x_misc.c gd32f10x_usart.c gd32f10x_exti.c gd32f10x_timer.c
